# Keil uVision project BH-F103.uvprojx, settings and files
target TIM—通用定时器-4路PWM输出 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIM—通用定时器-4路PWM输出 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\sys;..\..\User\Timer;..\..\User\stepping motor;..\..\User\Servo;..\..\User\usart;..\..\User\airpump;..\..\User\TimBase;..\..\User\limitswitch;..\..\User\logic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h main.c stm32f10x_it.c stm32f10x_it.h
    ../../User/sys/: sys.c
    ../../User/stepping motor/: steppingmotor.c
    ../../User/usart/: bsp_usart.c
    ../../User/airpump/: airpump.c
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/Servo/: Servo.c
    ../../User/limitswitch/: limitswitch.c
    ../../User/logic/: logic.c
  group DOC
    ../../Doc/: readme.txt record.txt
